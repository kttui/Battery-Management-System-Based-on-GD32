# Keil uVision project project.uvprojx, settings and files
target Target_1 (6070000::V6.7::.\ARMCLANG)
  device: GD32C113CB GigaDevice
  pack: GigaDevice.GD32C11x_DFP.1.5.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32C113CB
  c include: .\Libraries\GD32C11x_standard_peripheral;.\User;.\Code;.\Libraries\GD32C11x_standard_peripheral\Include;.\Libraries\GD32C11x_standard_peripheral\Source;.\Libraries\CMSIS\GD\GD32C11x\Include;.\Code\Bms\Core;.\Code\Bms\Hal;.\Code\Drivers;.\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;.\Middlewares\Third_Party\FreeRTOS\Source\include;.\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang;.\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1F800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/: systick.c main.c can.c freertos.c gpio.c usart.c FreeRTOSConfig.h gd32c11x_it.c
    ./Middlewares/Third_Party/RealThread_RTOS/include/: rtconfig.h
  group Code
    ./Code/Bms/: bms_app.c bms_config.h
    ./Code/Bms/Core/: bms_analysis.c bms_soc_store.c bms_comm.c bms_charger.c bms_energy.c bms_global.c bms_info.c bms_monitor.c bms_msh_commond.c bms_protect.c bms_utils.c
    ./Code/Bms/Hal/: bms_hal_comm.c bms_hal_config.c bms_hal_control.c bms_hal_monitor.c
    ./Code/Drivers/: drv_can.c drv_rs485.c drv_soft_i2c.c drv_softi2c_gd30bm2016.c
    ./Code/: board.c
  group Peripherals
    ./Libraries/GD32C11x_standard_peripheral/Include/: gd32c11x_adc.h gd32c11x_bkp.h gd32c11x_can.h gd32c11x_crc.h gd32c11x_ctc.h gd32c11x_dac.h gd32c11x_dbg.h gd32c11x_dma.h gd32c11x_exmc.h gd32c11x_exti.h gd32c11x_fmc.h gd32c11x_fwdgt.h gd32c11x_gpio.h gd32c11x_i2c.h gd32c11x_misc.h gd32c11x_pmu.h gd32c11x_rcu.h gd32c11x_rtc.h gd32c11x_spi.h gd32c11x_timer.h gd32c11x_usart.h gd32c11x_wwdgt.h
    ./Libraries/GD32C11x_standard_peripheral/Source/: gd32c11x_adc.c gd32c11x_bkp.c gd32c11x_can.c gd32c11x_crc.c gd32c11x_ctc.c gd32c11x_dac.c gd32c11x_dbg.c gd32c11x_dma.c gd32c11x_exmc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_fwdgt.c gd32c11x_gpio.c gd32c11x_i2c.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_rtc.c gd32c11x_spi.c gd32c11x_timer.c gd32c11x_usart.c gd32c11x_wwdgt.c
  group startup
    ./Libraries/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
    ./Libraries/CMSIS/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
  group freertos
    ./Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/include
    ./Middlewares/Third_Party/FreeRTOS/Source/include/: deprecated_definitions.h croutine.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/portable
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group cmsis
    ./Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c cmsis_os2.h
software components: CMSIS:CORE 5.0.1
